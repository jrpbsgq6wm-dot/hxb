# Keil uVision project svs_260210.uvprojx, settings and files
target iap_app_1.1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: svsapp +hex
  AfterMake: fromelf --bin --output "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\HARDWARE\LED;..\HARDWARE\SPI;..\APP\TDC_GP22;..\HARDWARE\EXTI;..\HARDWARE\UART;..\APP\SERIAL;..\APP\DELAY;..\HARDWARE\TIMER;..\HARDWARE\STM32FLASH;..\HARDWARE\DMA;..\HARDWARE\WDG
  asm define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  memory RVCT4: ROM 0x8004000 size 0xbc00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group APP
    ../APP/TDC_GP22/: tdc_gp22.c
    ../APP/SERIAL/: serial.c
    ../APP/DELAY/: delay.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/UART/: usart1.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/STM32FLASH/: stmflash.c
    ../HARDWARE/WDG/: wdg.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
