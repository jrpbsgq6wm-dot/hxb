# Keil uVision project CubeSVP1500.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F411RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SVPapp +hex
  AfterMake: fromelf --bin --output "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1
  c define: USE_HAL_DRIVER,STM32F411xE,
  c misc: --C99
  c include: ..\SYSTEM\delay;..\HALLIB\Inc;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\CORE;..\USB\USB_APP;..\HARDWARE\ADC;..\HARDWARE\LED;..\HARDWARE\SPI;..\HARDWARE\TIME;..\HALLIB\Inc\Legacy;..\HARDWARE\W25QXX;..\FATFS;..\HARDWARE\FAT;..\HARDWARE\EEPROM;..\HARDWARE\IIC;..\HARDWARE\MALLOC;..\HARDWARE\RTC;..\HARDWARE\KEY;..\HARDWARE\STMFLASH;..\HARDWARE\TDC_GP22;..\HARDWARE\EXTI;..\HARDWARE\DMA;..\HARDWARE\LTC2943;..\HARDWARE\SENSOR;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c freertos_app.c
  group CORE
    ../CORE/: cmsis_armcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_cm4.h startup_stm32f411xe.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TIME/: time.c workmode.c
    ../HARDWARE/ADC/: ad7124.c communication.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/EEPROM/: eeprom.c
    ../HARDWARE/IIC/: iic.c myiic.c
    ../HARDWARE/MALLOC/: malloc.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/TDC_GP22/: tdc_gp22.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/LTC2943/: ltc2943.c power_app.c
    ../HARDWARE/SENSOR/: svp_sensor.c
    ../HARDWARE/FAT/: file_fsm.c
  group HALLIB
    ../HALLIB/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_exti.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c
  group README
    ../: README.TXT
  group FATFS
    ../HARDWARE/FAT/: fat.c
    ../FATFS/: diskio.c ff.c ffsystem.c ffunicode.c
  group FreeRTOS_CORE
    ../Middlewares/FreeRTOS/: list.c queue.c tasks.c
  group FreeRTOS_PORT
    ../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../Middlewares/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
